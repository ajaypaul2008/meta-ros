DESCRIPTION = "Message and service data structures for interacting with Gazebo from ROS."
SECTION = "devel"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://package.xml;beginline=11;endline=11;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "geometry-msgs sensor-msgs trajectory-msgs std-msgs std-srvs message-generation"

require gazebo-ros-pkgs.inc
