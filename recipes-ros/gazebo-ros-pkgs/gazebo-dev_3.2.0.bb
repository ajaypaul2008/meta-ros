DESCRIPTION = "Provides a cmake config for the default version of Gazebo for the ROS distribution."
SECTION = "devel"
LICENSE = "Apache 2.0"
LIC_FILES_CHKSUM = "file://package.xml;beginline=12;endline=12;md5=d566ef916e9dedc494f5f793a6690ba5"

DEPENDS = "libgazebo7-dev gazebo"

require gazebo-ros-pkgs.inc
